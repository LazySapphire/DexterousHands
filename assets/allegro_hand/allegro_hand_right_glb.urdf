Commit message: bkup

File: assets/allegro_hand/allegro_hand_right_glb.urdf (robot description, URDF)
Before this commit: robot allegro_right, 23 links, 22 joints
Links:
- link base_link: mass 0.4154 -> 20
